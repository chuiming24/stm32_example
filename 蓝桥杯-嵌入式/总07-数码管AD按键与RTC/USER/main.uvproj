# Keil uVision project main.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\LCD_DRIVER;..\DRIVER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LCD
    ../LCD_DRIVER/: lcd.c
  group DRIVER
    ../DRIVER/scr/: led.c key.c adc.c usart.c eeprom.c i2c.c puls.c fre.c
