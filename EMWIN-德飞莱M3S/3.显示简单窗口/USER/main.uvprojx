# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWLib\inc;..\HARDWARE;..\SYSTEM;..\USER;..\HARDWARE\inc;..\SYSTEM\inc;..\EMWIN\EMWIN_inc;..\EMWIN\EMWIN_Config;..\EMWIN\EMWIN_Demo
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_xl.s
  group FWLib
    ../FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/src/: lcd.c
  group SYSTEM
    ../SYSTEM/src/: delay.c usart.c sys.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group EMWIN_Config
    ../EMWIN/EMWIN_Config/: GUI_X.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c SIMConf.c
  group EMWIN_LIB
    ../EMWIN/EMWIN_LIB/: STemWin526_CM3_Keil.lib
  group GUI
    ../GUI/: FramewinDLG.c
